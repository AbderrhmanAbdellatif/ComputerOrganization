# Keil uVision project firstAssemblyProg.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: firstAssemblyProg
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  group Source Group 1
    ./: anadosya.s
